# Keil uVision project Analog.uvproj, settings and files
target KL25Z Flash (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: Analog
  c flags: Optim=1
  c include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group Startup
    ./src/: system_MKL25Z4.c
    ./asm/: startup_MKL25Z4.s
  group Source Files
    ./src/: main.c gpio_aj.c sim_aj.c spi_aj.c WIFIApi.c
    ./: LEDs.c
  group Include Files
    ./inc/: LEDs.h user_defs.h gpio_aj.h sim_aj.h
    ./src/: spi_aj.h
